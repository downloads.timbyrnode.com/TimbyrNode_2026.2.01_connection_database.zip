Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Verification_STEP_C16_Frame-knee-dowel-circles_Manual.ifc
Time: 2026-08-11T22:46:10
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: DOWEL (46)
In: Storey
Type - PredefinedType: BEAM
Description: D24; Material: Steel S235
TimbyrNode Dowel - Name: DOWEL D24; Class: 101; Material: Steel; Grade: S235; Diameter: 24 mm; Shank Length: 400 mm

# IfcBeam: M1
In: Storey
Type - PredefinedType: BEAM
Description: 200x1400; Material: Timber GL24h
TimbyrNode Member - Name: M1; Material: Timber; Grade: GL24h; Cross Section: 200x1400; Width: 200 mm; Depth: 1400 mm

# IfcBeam: M2
In: Storey
Type - PredefinedType: BEAM
Description: 100x1400; Material: Timber GL24h
TimbyrNode Member - Name: M2; Material: Timber; Grade: GL24h; Cross Section: 100x1400; Width: 100 mm; Depth: 1400 mm

# IfcBeam: M2 (2)
In: Storey
Type - PredefinedType: BEAM
Description: 100x1400; Material: Timber GL24h
TimbyrNode Member - Name: M2 (2); Material: Timber; Grade: GL24h; Cross Section: 100x1400; Width: 100 mm; Depth: 1400 mm
