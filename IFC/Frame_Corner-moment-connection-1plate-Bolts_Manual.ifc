Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Frame_Corner-moment-connection-1plate-Bolts_Manual.ifc
Time: 2026-08-11T22:46:09
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: M1
In: Storey
Type - PredefinedType: BEAM
Description: 240x600; Material: Timber GL24h
TimbyrNode Member - Name: M1; Material: Timber; Grade: GL24h; Cross Section: 240x600; Width: 240 mm; Depth: 600 mm

# IfcBeam: M2
In: Storey
Type - PredefinedType: BEAM
Description: 240x600; Material: Timber GL24h
TimbyrNode Member - Name: M2; Material: Timber; Grade: GL24h; Cross Section: 240x600; Width: 240 mm; Depth: 600 mm

# IfcMechanicalFastener: Bolt assembly (48)
In: Storey
NominalDiameter: 16 mm; NominalLength: 228.8 mm; Material: Steel 8.8
TimbyrNode Bolt - Bolt Name: M16*229; Standard: DIN931; Material: Steel; Grade: 8.8; Diameter: 16 mm; Shank Length: 228.8 mm

# IfcPlate: PLATE
In: Storey
Type - PredefinedType: USERDEFINED
Description: GUSST_1; Material: Steel S355
TimbyrNode Plate - Name: GUSST_1; Material: Steel; Grade: S355; Thickness: 16 mm
