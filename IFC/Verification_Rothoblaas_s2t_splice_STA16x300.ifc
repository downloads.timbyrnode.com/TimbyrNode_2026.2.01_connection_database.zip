Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Verification_Rothoblaas_s2t_splice_STA16x300.ifc
Time: 2026-08-11T22:46:10
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: CH1
In: Storey
Type - PredefinedType: BEAM
Description: 300x300; Material: Timber GL24h
TimbyrNode Member - Name: CH1; Material: Timber; Grade: GL24h; Cross Section: 300x300; Width: 300 mm; Depth: 300 mm

# IfcBeam: CH2
In: Storey
Type - PredefinedType: BEAM
Description: 300x300; Material: Timber GL24h
TimbyrNode Member - Name: CH2; Material: Timber; Grade: GL24h; Cross Section: 300x300; Width: 300 mm; Depth: 300 mm

# IfcBeam: DOWEL (16)
In: Storey
Type - PredefinedType: BEAM
Description: D16; Material: Steel Rothoblaas STA 16
TimbyrNode Dowel - Name: DOWEL STA16300B; Class: 101; Material: Steel; Grade: Rothoblaas STA 16; Diameter: 16 mm; Shank Length: 300 mm; Product Code: STA16300B

# IfcPlate: PLATE (2)
In: Storey
Type - PredefinedType: USERDEFINED
Material: Steel S235
TimbyrNode Plate - Material: Steel; Grade: S235; Thickness: 8 mm
Name | Description = Name
PLATE | GUSST1a
PLATE | GUSST1b
