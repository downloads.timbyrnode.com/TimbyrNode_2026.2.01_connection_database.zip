Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Verification_SW-vol3-4-4_nailed_Manual.ifc
Time: 2026-08-11T22:46:10
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: M1
In: Storey
Type - PredefinedType: BEAM
Description: 215x315; Material: Timber GL30c
TimbyrNode Member - Name: M1; Material: Timber; Grade: GL30c; Cross Section: 215x315; Width: 215 mm; Depth: 315 mm

# IfcBeam: NAIL (60)
In: Storey
Type - PredefinedType: BEAM
Description: N4; Material: Steel fu 600
TimbyrNode Nail - Name: Nail D4; Material: Steel; Grade: fu 600; Diameter: 4 mm; Length: 60 mm; Fasteners per location: 2

# IfcPlate: PLATE (2)
In: Storey
Type - PredefinedType: USERDEFINED
Material: Steel S235
TimbyrNode Plate - Material: Steel; Grade: S235; Thickness: 5 mm
Name | Description = Name
PLATE | GUSST_1
PLATE | GUSST_2
