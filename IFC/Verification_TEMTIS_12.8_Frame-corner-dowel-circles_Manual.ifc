Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Verification_TEMTIS_12.8_Frame-corner-dowel-circles_Manual.ifc
Time: 2026-08-11T22:46:11
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: DOWEL (50)
In: Storey
Type - PredefinedType: BEAM
Description: D24; Material: Steel 240/400
TimbyrNode Dowel - Name: DOWEL D24; Class: 101; Material: Steel; Grade: Custom (f_y, f_u) (240/400); Diameter: 24 mm; Shank Length: 440 mm

# IfcBeam: M1
In: Storey
Type - PredefinedType: BEAM
Description: 200x1480; Material: Timber GL24h
TimbyrNode Member - Name: M1; Material: Timber; Grade: GL24h; Cross Section: 200x1480; Width: 200 mm; Depth: 1480 mm

# IfcBeam: M2
In: Storey
Type - PredefinedType: BEAM
Description: 120x1480; Material: Timber GL24h
TimbyrNode Member - Name: M2; Material: Timber; Grade: GL24h; Cross Section: 120x1480; Width: 120 mm; Depth: 1480 mm

# IfcBeam: M2 (2)
In: Storey
Type - PredefinedType: BEAM
Description: 120x1480; Material: Timber GL24h
TimbyrNode Member - Name: M2 (2); Material: Timber; Grade: GL24h; Cross Section: 120x1480; Width: 120 mm; Depth: 1480 mm
