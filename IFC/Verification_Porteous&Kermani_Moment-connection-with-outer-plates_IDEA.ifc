Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Verification_Porteous&Kermani_Moment-connection-with-outer-plates_IDEA.ifc
Time: 2026-08-11T22:46:10
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: B
In: Storey
Type - PredefinedType: BEAM
Description: 72x294; Material: Timber GL24h
TimbyrNode Member - Name: B; Material: Timber; Grade: GL24h; Cross Section: 72x294; Width: 72 mm; Depth: 294 mm

# IfcBeam: C
In: Storey
Type - PredefinedType: BEAM
Description: 72x304; Material: Timber GL24h
TimbyrNode Member - Name: C; Material: Timber; Grade: GL24h; Cross Section: 72x304; Width: 72 mm; Depth: 304 mm

# IfcMechanicalFastener: Bolt assembly (16)
In: Storey
NominalDiameter: 12 mm; NominalLength: 117.8 mm; Material: Steel 8.8
TimbyrNode Bolt - Bolt Name: M12*118; Standard: DIN931; Material: Steel; Grade: 8.8; Diameter: 12 mm; Shank Length: 117.8 mm

# IfcPlate: PLATE (2)
In: Storey
Type - PredefinedType: USERDEFINED
Material: Steel S 355
TimbyrNode Plate - Material: Steel; Grade: S 355; Thickness: 12 mm
Name | Description = Name
PLATE | GUSST1a
PLATE | GUSST1b
