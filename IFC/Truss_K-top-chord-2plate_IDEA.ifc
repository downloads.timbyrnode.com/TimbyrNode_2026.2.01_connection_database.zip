Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Truss_K-top-chord-2plate_IDEA.ifc
Time: 2026-08-11T22:46:09
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: CH
In: Storey
Type - PredefinedType: BEAM
Description: 280x400; Material: Timber GL24h
TimbyrNode Member - Name: CH; Material: Timber; Grade: GL24h; Cross Section: 280x400; Width: 280 mm; Depth: 400 mm

# IfcBeam: D2
In: Storey
Type - PredefinedType: BEAM
Description: 280x240; Material: Timber GL24h
TimbyrNode Member - Name: D2; Material: Timber; Grade: GL24h; Cross Section: 280x240; Width: 280 mm; Depth: 240 mm

# IfcBeam: D3
In: Storey
Type - PredefinedType: BEAM
Description: 280x240; Material: Timber GL24h
TimbyrNode Member - Name: D3; Material: Timber; Grade: GL24h; Cross Section: 280x240; Width: 280 mm; Depth: 240 mm

# IfcMechanicalFastener: Bolt assembly (31)
In: Storey
NominalDiameter: 12 mm; NominalLength: 271.8 mm; Material: Steel 8.8
TimbyrNode Bolt - Bolt Name: M12*272; Standard: DIN931; Material: Steel; Grade: 8.8; Diameter: 12 mm; Shank Length: 271.8 mm

# IfcPlate: PLATE (2)
In: Storey
Type - PredefinedType: USERDEFINED
Material: Steel S 355
TimbyrNode Plate - Material: Steel; Grade: S 355; Thickness: 10 mm
Name | Description = Name
PLATE | GUSST1a
PLATE | GUSST1b
