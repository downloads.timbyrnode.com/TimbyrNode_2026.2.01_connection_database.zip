Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Verification_Porteous&Kermani_Moment-connection-with-outer-plates_Manual.ifc
Time: 2026-08-11T22:46:10
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: B
In: Storey
Type - PredefinedType: BEAM
Description: 72x294; Material: Timber C24
TimbyrNode Member - Name: B; Material: Timber; Grade: C24; Cross Section: 72x294; Width: 72 mm; Depth: 294 mm

# IfcBeam: C
In: Storey
Type - PredefinedType: BEAM
Description: 72x304; Material: Timber C24
TimbyrNode Member - Name: C; Material: Timber; Grade: C24; Cross Section: 72x304; Width: 72 mm; Depth: 304 mm

# IfcMechanicalFastener: Bolt assembly (16)
In: Storey
NominalDiameter: 12 mm; NominalLength: 117.8 mm; Material: Steel 4.6
TimbyrNode Bolt - Bolt Name: M12*118; Standard: DIN931; Material: Steel; Grade: 4.6; Diameter: 12 mm; Shank Length: 117.8 mm

# IfcPlate: PLATE (2)
In: Storey
Type - PredefinedType: USERDEFINED
Material: Steel S355
TimbyrNode Plate - Material: Steel; Grade: S355; Thickness: 12 mm
Name | Description = Name
PLATE | GUSST_1
PLATE | GUSST_2
