Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Verification_PK_10.13.3_t2t-lap-single-bolt_Manual.ifc
Time: 2026-08-11T22:46:10
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: M1
In: Storey
Type - PredefinedType: BEAM
Description: 50x150; Material: Timber C18
TimbyrNode Member - Name: M1; Material: Timber; Grade: C18; Cross Section: 50x150; Width: 50 mm; Depth: 150 mm

# IfcBeam: M1 (2)
In: Storey
Type - PredefinedType: BEAM
Description: 50x150; Material: Timber C18
TimbyrNode Member - Name: M1 (2); Material: Timber; Grade: C18; Cross Section: 50x150; Width: 50 mm; Depth: 150 mm

# IfcBeam: M2
In: Storey
Type - PredefinedType: BEAM
Description: 50x150; Material: Timber C18
TimbyrNode Member - Name: M2; Material: Timber; Grade: C18; Cross Section: 50x150; Width: 50 mm; Depth: 150 mm

# IfcBeam: M2 (2)
In: Storey
Type - PredefinedType: BEAM
Description: 50x150; Material: Timber C18
TimbyrNode Member - Name: M2 (2); Material: Timber; Grade: C18; Cross Section: 50x150; Width: 50 mm; Depth: 150 mm

# IfcBeam: M3
In: Storey
Type - PredefinedType: BEAM
Description: 70x150; Material: Timber C18
TimbyrNode Member - Name: M3; Material: Timber; Grade: C18; Cross Section: 70x150; Width: 70 mm; Depth: 150 mm

# IfcMechanicalFastener: Bolt assembly
In: Storey
NominalDiameter: 12 mm; NominalLength: 291.8 mm; Material: Steel 4.6
TimbyrNode Bolt - Bolt Name: M12*292; Standard: DIN931; Material: Steel; Grade: 4.6; Diameter: 12 mm; Shank Length: 291.8 mm
