Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Verification_PK-10-13-1_nailed_lap_Manual.ifc
Time: 2026-08-11T22:46:10
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: M1
In: Storey
Type - PredefinedType: BEAM
Description: 50x150; Material: Timber C22
TimbyrNode Member - Name: M1; Material: Timber; Grade: C22; Cross Section: 50x150; Width: 50 mm; Depth: 150 mm

# IfcBeam: M2
In: Storey
Type - PredefinedType: BEAM
Description: 36x150; Material: Timber C22
TimbyrNode Member - Name: M2; Material: Timber; Grade: C22; Cross Section: 36x150; Width: 36 mm; Depth: 150 mm

# IfcBeam: M2 (2)
In: Storey
Type - PredefinedType: BEAM
Description: 36x150; Material: Timber C22
TimbyrNode Member - Name: M2 (2); Material: Timber; Grade: C22; Cross Section: 36x150; Width: 36 mm; Depth: 150 mm

# IfcBeam: NAIL (9)
In: Storey
Type - PredefinedType: BEAM
Description: N3.35; Material: Steel fu 600
TimbyrNode Nail - Name: Nail D3.35; Material: Steel; Grade: fu 600; Diameter: 3.35 mm; Length: 65 mm; Fasteners per location: 2
