Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Verification_COST_FP1402_IDEA.ifc
Time: 2026-08-11T22:46:10
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: CH1
In: Storey
Type - PredefinedType: BEAM
Description: 300x160; Material: Timber GL24h
TimbyrNode Member - Name: CH1; Material: Timber; Grade: GL24h; Cross Section: 300x160; Width: 300 mm; Depth: 160 mm

# IfcBeam: CH2
In: Storey
Type - PredefinedType: BEAM
Description: 300x160; Material: Timber GL24h
TimbyrNode Member - Name: CH2; Material: Timber; Grade: GL24h; Cross Section: 300x160; Width: 300 mm; Depth: 160 mm

# IfcMechanicalFastener: Bolt assembly (16)
In: Storey
NominalDiameter: 16 mm; NominalLength: 328.8 mm; Material: Steel 8.8
TimbyrNode Bolt - Bolt Name: M16*329; Standard: DIN931; Material: Steel; Grade: 8.8; Diameter: 16 mm; Shank Length: 328.8 mm

# IfcPlate: PLATE (2)
In: Storey
Type - PredefinedType: USERDEFINED
Material: Steel S 355
TimbyrNode Plate - Material: Steel; Grade: S 355; Thickness: 10 mm
Name | Description = Name
PLATE | GUSST1a
PLATE | GUSST1b
