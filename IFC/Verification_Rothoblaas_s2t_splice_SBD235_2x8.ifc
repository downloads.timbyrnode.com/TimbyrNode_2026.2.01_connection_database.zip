Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Verification_Rothoblaas_s2t_splice_SBD235_2x8.ifc
Time: 2026-08-11T22:46:10
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: CH1
In: Storey
Type - PredefinedType: BEAM
Description: 240x300; Material: Timber GL24h
TimbyrNode Member - Name: CH1; Material: Timber; Grade: GL24h; Cross Section: 240x300; Width: 240 mm; Depth: 300 mm

# IfcBeam: CH2
In: Storey
Type - PredefinedType: BEAM
Description: 240x300; Material: Timber GL24h
TimbyrNode Member - Name: CH2; Material: Timber; Grade: GL24h; Cross Section: 240x300; Width: 240 mm; Depth: 300 mm

# IfcBeam: DOWEL (16)
In: Storey
Type - PredefinedType: BEAM
Description: D7.5; Material: Steel Rothoblaas SBD 7.5
TimbyrNode Dowel - Name: DOWEL SBD75235; Class: 101; Material: Steel; Grade: Rothoblaas SBD 7.5; Diameter: 7.5 mm; Shank Length: 235 mm; Product Code: SBD75235

# IfcPlate: PLATE (2)
In: Storey
Type - PredefinedType: USERDEFINED
Material: Steel S235
TimbyrNode Plate - Material: Steel; Grade: S235; Thickness: 8 mm
Name | Description = Name
PLATE | GUSST1a
PLATE | GUSST1b
