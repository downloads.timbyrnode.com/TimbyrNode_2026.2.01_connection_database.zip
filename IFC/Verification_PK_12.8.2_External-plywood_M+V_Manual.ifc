Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Verification_PK_12.8.2_External-plywood_M+V_Manual.ifc
Time: 2026-08-11T22:46:10
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: M1
In: Storey
Type - PredefinedType: BEAM
Description: 75x300; Material: Timber C27
TimbyrNode Member - Name: M1; Material: Timber; Grade: C27; Cross Section: 75x300; Width: 75 mm; Depth: 300 mm

# IfcMechanicalFastener: Bolt assembly (8)
In: Storey
NominalDiameter: 12 mm; NominalLength: 96.8 mm; Material: Steel 4.6
TimbyrNode Bolt - Bolt Name: M12*97; Standard: DIN931; Material: Steel; Grade: 4.6; Diameter: 12 mm; Shank Length: 96.8 mm

# IfcPlate: PLATE (2)
In: Storey
Type - PredefinedType: USERDEFINED
Material: Plywood
TimbyrNode Plate - Material: Plywood; Thickness: 24 mm
Name | Description = Name
PLATE | PLY_1
PLATE | PLY_2
