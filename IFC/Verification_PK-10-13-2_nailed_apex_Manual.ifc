Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Verification_PK-10-13-2_nailed_apex_Manual.ifc
Time: 2026-08-11T22:46:10
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: M1
In: Storey
Type - PredefinedType: BEAM
Description: 50x100; Material: Timber C18
TimbyrNode Member - Name: M1; Material: Timber; Grade: C18; Cross Section: 50x100; Width: 50 mm; Depth: 100 mm

# IfcBeam: M2L
In: Storey
Type - PredefinedType: BEAM
Description: 50x125; Material: Timber C18
TimbyrNode Member - Name: M2L; Material: Timber; Grade: C18; Cross Section: 50x125; Width: 50 mm; Depth: 125 mm

# IfcBeam: M2R
In: Storey
Type - PredefinedType: BEAM
Description: 50x125; Material: Timber C18
TimbyrNode Member - Name: M2R; Material: Timber; Grade: C18; Cross Section: 50x125; Width: 50 mm; Depth: 125 mm

# IfcBeam: NAIL (18)
In: Storey
Type - PredefinedType: BEAM
Description: N3; Material: Steel fu 600
TimbyrNode Nail - Name: Nail D3; Material: Steel; Grade: fu 600; Diameter: 3 mm; Length: 50 mm; Fasteners per location: 2

# IfcPlate: PLATE (2)
In: Storey
Type - PredefinedType: USERDEFINED
Material: Plywood
TimbyrNode Plate - Material: Plywood; Thickness: 12 mm
Name | Description = Name
PLATE | PLY_1
PLATE | PLY_2
