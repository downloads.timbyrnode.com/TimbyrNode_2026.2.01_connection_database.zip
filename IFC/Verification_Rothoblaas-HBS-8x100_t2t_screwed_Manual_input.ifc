Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Verification_Rothoblaas-HBS-8x100_t2t_screwed_Manual_input.ifc
Time: 2026-08-11T22:46:10
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: M1
In: Storey
Type - PredefinedType: BEAM
Description: 60x200; Material: Timber C24
TimbyrNode Member - Name: M1; Material: Timber; Grade: C24; Cross Section: 60x200; Width: 60 mm; Depth: 200 mm

# IfcBeam: M2
In: Storey
Type - PredefinedType: BEAM
Description: 60x200; Material: Timber C24
TimbyrNode Member - Name: M2; Material: Timber; Grade: C24; Cross Section: 60x200; Width: 60 mm; Depth: 200 mm

# IfcBeam: M2 (2)
In: Storey
Type - PredefinedType: BEAM
Description: 60x200; Material: Timber C24
TimbyrNode Member - Name: M2 (2); Material: Timber; Grade: C24; Cross Section: 60x200; Width: 60 mm; Depth: 200 mm

# IfcBeam: SCREW (32)
In: Storey
Type - PredefinedType: BEAM
Description: S8; Material: Steel fu 600
TimbyrNode Screw - Name: Screw D8; Material: Steel; Grade: fu 600; Diameter: 8 mm; Length: 100 mm; Fasteners per location: 2
