Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Verification_PK_10.13.4_t2t-boom-2bolt_Manual.ifc
Time: 2026-08-11T22:46:10
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: M1
In: Storey
Type - PredefinedType: BEAM
Description: 37x200; Material: Timber C18
TimbyrNode Member - Name: M1; Material: Timber; Grade: C18; Cross Section: 37x200; Width: 37 mm; Depth: 200 mm

# IfcBeam: M2
In: Storey
Type - PredefinedType: BEAM
Description: 47x175; Material: Timber C18
TimbyrNode Member - Name: M2; Material: Timber; Grade: C18; Cross Section: 47x175; Width: 47 mm; Depth: 175 mm

# IfcBeam: M2 (2)
In: Storey
Type - PredefinedType: BEAM
Description: 47x175; Material: Timber C18
TimbyrNode Member - Name: M2 (2); Material: Timber; Grade: C18; Cross Section: 47x175; Width: 47 mm; Depth: 175 mm

# IfcBeam: M3
In: Storey
Type - PredefinedType: BEAM
Description: 47x225; Material: Timber C18
TimbyrNode Member - Name: M3; Material: Timber; Grade: C18; Cross Section: 47x225; Width: 47 mm; Depth: 225 mm

# IfcBeam: M3 (2)
In: Storey
Type - PredefinedType: BEAM
Description: 47x225; Material: Timber C18
TimbyrNode Member - Name: M3 (2); Material: Timber; Grade: C18; Cross Section: 47x225; Width: 47 mm; Depth: 225 mm

# IfcMechanicalFastener: Bolt assembly (2)
In: Storey
NominalDiameter: 16 mm; NominalLength: 253.8 mm; Material: Steel 4.6
TimbyrNode Bolt - Bolt Name: M16*254; Standard: DIN931; Material: Steel; Grade: 4.6; Diameter: 16 mm; Shank Length: 253.8 mm
