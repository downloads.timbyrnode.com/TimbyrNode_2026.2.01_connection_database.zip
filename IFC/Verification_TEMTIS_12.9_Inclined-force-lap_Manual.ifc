Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Verification_TEMTIS_12.9_Inclined-force-lap_Manual.ifc
Time: 2026-08-11T22:46:11
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: CH
In: Storey
Type - PredefinedType: BEAM
Description: 48x198; Material: Timber C30
TimbyrNode Member - Name: CH; Material: Timber; Grade: C30; Cross Section: 48x198; Width: 48 mm; Depth: 198 mm

# IfcBeam: CH (2)
In: Storey
Type - PredefinedType: BEAM
Description: 48x198; Material: Timber C30
TimbyrNode Member - Name: CH (2); Material: Timber; Grade: C30; Cross Section: 48x198; Width: 48 mm; Depth: 198 mm

# IfcBeam: D1
In: Storey
Type - PredefinedType: BEAM
Description: 48x148; Material: Timber C30
TimbyrNode Member - Name: D1; Material: Timber; Grade: C30; Cross Section: 48x148; Width: 48 mm; Depth: 148 mm

# IfcMechanicalFastener: Bolt assembly (4)
In: Storey
NominalDiameter: 14 mm; NominalLength: 169.8 mm; Material: Steel 8.8
TimbyrNode Bolt - Bolt Name: M14*170; Standard: DIN931; Material: Steel; Grade: 8.8; Diameter: 14 mm; Shank Length: 169.8 mm
