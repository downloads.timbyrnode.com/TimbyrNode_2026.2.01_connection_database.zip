Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Verification_Porteous&Kermani_Apex-connection-with-1-inserted-plate_IDEA.ifc
Time: 2026-08-11T22:46:10
Author: TimbyrNode
Organization: TimbyrNode
Written by: TimbyrNode IFC Export
Made in: 2026.2.01

# IfcAnnotation, Node
In: Storey
Description: Connection node tri-axis marker

# IfcBeam: CH1
In: Storey
Type - PredefinedType: BEAM
Description: 75x300; Material: Timber GL24h
TimbyrNode Member - Name: CH1; Material: Timber; Grade: GL24h; Cross Section: 75x300; Width: 75 mm; Depth: 300 mm

# IfcBeam: CH2
In: Storey
Type - PredefinedType: BEAM
Description: 75x300; Material: Timber GL24h
TimbyrNode Member - Name: CH2; Material: Timber; Grade: GL24h; Cross Section: 75x300; Width: 75 mm; Depth: 300 mm

# IfcBeam: D1
In: Storey
Type - PredefinedType: BEAM
Description: 75x100; Material: Timber GL24h
TimbyrNode Member - Name: D1; Material: Timber; Grade: GL24h; Cross Section: 75x100; Width: 75 mm; Depth: 100 mm

# IfcMechanicalFastener: Bolt assembly (19)
In: Storey
NominalDiameter: 12 mm; NominalLength: 96.8 mm; Material: Steel 8.8
TimbyrNode Bolt - Bolt Name: M12*97; Standard: DIN931; Material: Steel; Grade: 8.8; Diameter: 12 mm; Shank Length: 96.8 mm

# IfcPlate: PLATE
In: Storey
Type - PredefinedType: USERDEFINED
Description: GUSST1; Material: Steel S 355
TimbyrNode Plate - Name: GUSST1; Material: Steel; Grade: S 355; Thickness: 8 mm
